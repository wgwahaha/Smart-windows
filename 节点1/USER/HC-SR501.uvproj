# Keil uVision project HC-SR501.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: HC-SR501 +hex
  c flags: Optim=1
  c define: STM32F1OX_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE;..\SYSTEM\delay;..\USER;..\SYSTEM\sys;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/: led.c time.c usart2.c time1.c
