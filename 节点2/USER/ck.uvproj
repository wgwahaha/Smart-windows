# Keil uVision project ck.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: ck +hex
  c flags: Optim=1
  c define: STM32F1OX_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE;..\SYSTEM;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: system_stm32f10x.c stm32f10x_it.c main.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/: usart2.c usart3.c timer.c led.c time1.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
